# IAR project YASN_Watch.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: CC430F6137 CC430F6137
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: DEBUG
  ICC430.newCCIncludePaths: Include; TI_RadioDriver
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnkCC430F6137.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  ICC430.CCDefines: RELEASE
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  group (top)
    Source/: button.c com.c data.c display.c event.c flash.c main.c scheduler.c temperature.c timer.c transceiver.c
    TI_RadioDriver/: hal_pmm.c RF1A.c RfRegSettings.c
